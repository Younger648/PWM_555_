# Keil uVision project pwm.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: pwm +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\sourse
  group main
    ../sourse/: main.c
  group c
    ../sourse/: hc138.c SMG.c key.c head.c led.c
  group head
    ../sourse/: hc138.h SMG.h config.h key.h head.h led.h
